DESCRIPTION = "PLC4TRUCKSDUCK installation for BeagleBone Black"
LICENSE = "CLOSED"



